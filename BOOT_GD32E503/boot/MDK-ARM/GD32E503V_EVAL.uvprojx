# Keil uVision project GD32E503V_EVAL.uvprojx, settings and files
target GD32E503V_EVAL (6160000::V6.16::ARMCLANG)
  device: GD32E503VC GigaDevice
  pack: GigaDevice.GD32E50x_DFP.1.3.1
  cpu: IRAM(0x20000000,0x18000) IROM(0x08000000,0x040000) CPUTYPE("Cortex-M33") FPU3(SFPU) DSP CLOCK(12000000) ELITTLE
  output: PPS_Boot +hex
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: GD32E50X,GD32E50X_HD,USE_STDPERIPH_DRIVER
  c include: ..\.;..\Utilities;..\GD32E50x_Firmware_Library\CMSIS\GD\GD32E50x\Include;..\GD32E50x_Firmware_Library\GD32E50x_standard_peripheral\Include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x4000
  memory RVCT9: RAM 0x20000000 size 0x18000
  group Application
    ../: main.c gd32e50x_it.c serial.c timer.c
    ../GD32E50x_Firmware_Library/GD32E50x_standard_peripheral/Source/: gd32e50x_exti.c
  group CMSIS
    ../GD32E50x_Firmware_Library/CMSIS/GD/GD32E50x/Source/: system_gd32e50x.c
  group GD32E50x_Peripherals
    ../GD32E50x_Firmware_Library/GD32E50x_standard_peripheral/Source/: gd32e50x_rcu.c gd32e50x_fmc.c gd32e50x_fwdgt.c gd32e50x_gpio.c gd32e50x_misc.c gd32e50x_timer.c gd32e50x_usart.c gd32e50x_bkp.c gd32e50x_pmu.c
  group GD32E50x_EVAL
    ../Utilities/: gd32e503v_eval.c
  group Startup
    ../GD32E50x_Firmware_Library/CMSIS/GD/GD32E50x/Source/ARM/: startup_gd32e50x_hd.s
  group Doc
    ../: readme.txt
software components: CMSIS:CORE 5.4.0
